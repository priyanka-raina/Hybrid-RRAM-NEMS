* Flattened netlist generated by TxNetwork module of SiS
.subckt INVX1 A Y
mx_sis_top.xnr1/mn1 y a 0 0 n dtemp=0 l=1e-07 m=1 w=1.9e-07
mx_sis_top.xnr1/mp1 y a vdd vdd p dtemp=0 l=1e-07 m=1 w=4.15e-07
.ends INVX1
