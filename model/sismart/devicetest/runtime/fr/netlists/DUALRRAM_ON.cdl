* Flattened netlist generated by TxNetwork module of SiS
.subckt DUALRRAM_ON Vout
.ends DUALRRAM_ON
