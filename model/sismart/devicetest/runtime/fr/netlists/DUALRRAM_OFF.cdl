* Flattened netlist generated by TxNetwork module of SiS
.subckt DUALRRAM_OFF Vout
.ends DUALRRAM_OFF
