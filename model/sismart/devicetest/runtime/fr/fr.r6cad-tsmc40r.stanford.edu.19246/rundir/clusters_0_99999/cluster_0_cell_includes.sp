* all spice .includes for cell - cluster_0
.include '/home/akashl/Hybrid-RRAM-NEMS/model/sismart/devicetest/runtime/fr/fr.r6cad-tsmc40r.stanford.edu.19246/rundir/netlists/cluster_0_master.sp'
