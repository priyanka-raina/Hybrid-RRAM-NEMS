**** name - short name map
** y                                       	n12849a20
** a                                       	n12849a08
** 0                                       	0
** vb                                      	n12849188
** vdd                                     	n12849170
** gnd                                     	n12849158
** x_design_cluster_0_cluster_0            	x12226f60
**** name - short name map

* Spice file generated from Magma DataBase.
* Date: Mon Jun 24 06:44:47 2019

* Bedrock Root: Magma_root
x12226f60 n12849a20 n12849a08 cluster_0

.include '/home/akashl/Hybrid-RRAM-NEMS/model/sismart/devicetest/runtime/fr/fr.r6cad-tsmc40r.stanford.edu.19246/rundir/clusters_0_99999/cluster_0_masters_short.sp'
*magma_internal !rc_root y y^-
*magma_internal !rc_root a a^-
* Finished writing spice file on Date: Mon Jun 24 06:44:47 2019
